#include<Wire.h>    

#define DHT11PIN 4
dht11 DHT11;
#define SCREEN_WIDTH 128
#define SCREEN_HEIGHT 64
Adafruit_SSD1306 display(SCREEN,WIDTH,SCREEN,HEIGHT,&Wire,-1);
void setup()
{
  Serial.begin(115200);
  if(!display.begin(SSD1306_SWITCHCAPVCC,0x3C){
    Serial.println("SSD1306 allocation failed");
    for(;;);
  }
  delay(2000);
  display.clearDisplay();
  display.setTextColor(WHITE);
}
void loop()
{
  delay(5000);
  int chk=DHT11.read(DHT11PIN);
  float t= DHT11.temperature;
  float h= DHT11.humidity;
  if(isnan(h)|| isnan(t)){
    Serial.println("Failed to read form DHT sensor!");
  }
  display.clearDisplay();
  display.setTextSize(1);    
  display.setCursor(0,0);
  display.print("Temperature:");
  display.setTextSize(2);
  display.setCursor(0,10);
  display.print(t);
  display.write(167);
  display.print("C");
  display.setTextSize(1);
  display.setCursor(0,35);
  display.print("Humidity:");
  display.setTextSize(2);
  display.setCursor(0,45);
  display.print(h);
  display.print("%");
  display.display();
}


  
  
     